Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-12-18T16:09:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 18 16:09:08 2020 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{CC53C222-D381-48A3-98C4-C920C6503055}\ifc * Database version: 5507 * Database creation date: Fri Dec 18 16:09:08 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 18 16:09:08 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 18 16:09:08 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 4810F Washbasin faucet, 4810F(2021):4810F Washbasin faucet:395519
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 143.806 mm; NominalHeight: 175.838 mm; NominalWidth: 48.5 mm; Projection: 113 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 4810F(2021); ConvergoRefNr: 0087-2012-0002-FI; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/12/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150097003; EN Standard: EN 817; LVI Number: 6110343; VVS Number: 701385304
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/4810F; Catalog Drawing URL: http://static.oras.com/catdrw/4810F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/4810F; FDV Document URL: http://www.oras.com/datasheet/4810F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/4810F; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 4810F Washbasin faucet; Name_en: 4810F Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Product Code: 4810F; Product Datasheet: http://www.oras.com/datasheet/4810F/en; Product Family: Oras Stela; Product Image URL: http://static.oras.com/image/4810F; Product URL: http://static.oras.com/4810F; Technical DataSheet URL: http://www.oras.com/datasheet/4810F/en; Type Name: 4810F Washbasin faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;3S-Installation; Aerator: Laminar; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00317832 m3/s; Installation and Maintenance: http://static.oras.com/manual/4810F; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Noise Class: I (ISO 3822); Not Included: WithoutPopupWaste; Spare Parts: http://static.oras.com/sp/4810F; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 4810F(2021); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 4810F; Name: 4810F Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x145x175 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 4810F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 4810F Washbasin faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0418888 m2; Volume: 0.00123111 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 4810F(2021): 4810F Washbasin faucet; Family and Type: 4810F(2021): 4810F Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 4810F(2021): 4810F Washbasin faucet; Type Id: 4810F(2021): 4810F Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
